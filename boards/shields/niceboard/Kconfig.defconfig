## boards/shields/niceboard/Kconfig.defconfig
```kconfig
if SHIELD_NICEBOARD

config ZMK_KEYBOARD_NAME
    default "Nice!Board"

endif # SHIELD_NICEBOARD
```
